# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F091CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F091
  c include: .\Library;.\Startup;.\User;.\System
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: core_cm0.h core_cm0plus.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h core_cmFunc.h core_cmInstr.h startup_stm32f091.s
  group Library
    ./Library/: stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_can.c stm32f0xx_can.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_crs.c stm32f0xx_crs.h stm32f0xx_dac.c stm32f0xx_dac.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h
  group System
    ./System/: SysDelay.c SysDelay.h
  group User
    ./User/: main.c main.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
